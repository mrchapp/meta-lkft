PACKAGECONFIG_append = " chamelium"
