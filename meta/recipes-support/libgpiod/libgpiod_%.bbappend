PACKAGECONFIG = "tests"
